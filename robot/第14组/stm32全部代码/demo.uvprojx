# Keil uVision project demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Lib\inc;.\Lib\src;.\Startup;.\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_usart.c
    ./Lib/inc/: stm32f10x_tim.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_usart.h
  group User
    ./User/: main.c stm32f10x_it.c delay.c delay.h key.c key.h tim.c tim.h init.c init.h servo.c servo.h ultrasound.c ultrasound.h
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
software components: CMSIS:CORE 5.1.2, Device:GPIO 1.3
